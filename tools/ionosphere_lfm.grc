options:
  parameters:
    generate_options: qt_gui
    id: ionosphere_lfm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: sr
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: taps
  id: variable
  parameters:
    value: np.fromfile("/Users/owenohlson/Documents/Academics:Career/UVic/ionospheric_sounding/data/lfm_mf_taps.c64", dtype=np.complex64)
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: int(0.002 * sr)
    type: complex
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: int(0.005 * sr)
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/owenohlson/Documents/Academics:Career/UVic/ionospheric_sounding/data/lfm_chirp.c64
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1024'
    n: '96000'
    offset: '48000'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block\"\"\"\n\n    def __init__(self, taps_file=\"/Users/owenohlson/Documents/Academics:Career/UVic/ionospheric_sounding/data/lfm_mf_taps.c64\"):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='LFM Matched Filter',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n\n        # Load mf taps\n        self.taps = np.fromfile(taps_file, dtype=np.complex64)\n        self.ntaps = len(self.taps)\n\n        # Internal delay line\n        self.buffer = np.zeros(self.ntaps, dtype=np.complex64)\n\n    def work(self, input_items, output_items):\n        inp = input_items[0]\n        out = output_items[0]\n\n        for i in range(len(inp)):\n            # Shift delay line\n            self.buffer[1:] = self.buffer[:-1]\n            self.buffer[0] = inp[i]\n\n            # FIR dot product\n            out[i] = np.dot(self.buffer, self.taps)\n        \n        return len(out)\n\n"
    taps_file: ''
  states: {state: disabled}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: '1024'
    nrows: '100'
    samp_rate: sr
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: sr
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '96000'
    srate: sr
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: a
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: a
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '0']
- [blocks_add_xx_0, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_1, '0', virtual_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_delay_2, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_file_source_0, '0', blocks_delay_0, '0']
- [blocks_file_source_0, '0', blocks_delay_1, '0']
- [blocks_file_source_0, '0', blocks_delay_2, '0']
- [blocks_keep_m_in_n_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_keep_m_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '1']
- [blocks_nlog10_ff_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_1, '0']
- [fft_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
